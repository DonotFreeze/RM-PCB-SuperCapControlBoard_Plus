# Repository DonotFreeze/RM-PCB-SuperCapControlBoard_Plus

File README.md:

# 超级电容控制板 Plus

> 桂林理工大学 · 群星战队 · RoboMaster 2025 赛季开源工程

基于 **STM32G431CB** 的单半桥双向同步 Buck-Boost 超级电容控制板，用于RobaMaster机甲大师赛2025赛季超级对抗赛。相较 2024 赛季开源的 Lite 版本，Plus 版本围绕**远端电压补偿**、**下管电流采样**与**硬件保护**三个方面进行了重点改进，并重新设计了充放电环路逻辑。

> **完整的硬件设计说明** → [RM2025 超级电容控制板 Plus「硬件篇」 · DonotFreeze 的知识库](https://donotfreeze.github.io/robomaster/supercap-controller-plus-hardware/)

## 主要特性

- **远端电压补偿**：通过 MMCX-KWE 接口 + 差分放大器，把电压采样点从板端移到电源管理模块 Chassis 端口，抵消导线线损带来的功率采样误差（24V、0–10A 范围内与裁判系统误差 ≤ ±1W，未补偿时误差约 -5W）。
- **下管续流电流采样**：采用差分放大器进行下管低边采样，搭配 2mΩ 检流电阻，量程 -20A ~ +40A（充电为负、放电为正），有效电流分辨率约 0.1A，取代 Lite 版本的 INA181。节省成本的同时提高可靠性，但是在一定程度上损失了精度。
- **硬件保护**：母线电源端口带有 TVS、并在半桥拓扑支路上有一个5A慢断保险丝，可在一定程度上保证控制板烧毁而不影响母线。辅助电源有自恢复保险丝 + 限流电阻 + 小功率 TVS 的浪涌保护。功率相关引脚 ESD 防护及其熔断检测、PMOS 与 PWM 的硬件时序延迟电路。
- **单电感同步半桥**：PMOS 防倒灌 + 半桥 Buck/Boost，配合硬件/软件时序控制保证 PMOS 先于 PWM 导通、后于 PWM 关断。

## 硬件规格

| 项目 | 参数 |
| --- | --- |
| 主控 | STM32G431CBT6 |
| 拓扑 | 同步 Buck-Boost 半桥（降压充电 / 升压放电） |
| 半桥 MOS | IRFH7440 × 2 |
| 防倒灌 PMOS | AGM60P100A |
| 栅极驱动 | LM5109 |
| 母线电流采样 | 4mΩ + INA139/INA193 兼容 |
| 电流采样 | 2mΩ 分流电阻 + 差分放大器 |
| 温度采样 | 半桥温度NTC + 外接电容组NTC |
| 通信 | CAN |
| 辅助电源 | MP2456 × 2 + RT9193（3.3V） |
| 尺寸 | 45 × 75 × 20 mm（面积与孔位与电容组一致，可直接堆叠） |

## 工程结构

```text
├─ SuperCapControlBoard_Plus.kicad_pro / .kicad_sch / .kicad_pcb   # KiCad 8.0 工程（原理图 + PCB）
├─ POWER.kicad_sch                     # 功率级原理图
├─ BOM/
│  ├─ SuperCapPowerBoard_Plus.csv      # 已附立创商城编号的 BOM
│  └─ ibom.html                        # 交互式 BOM（点击可定位元件）
├─ GERBER/                             # Gerber 生产文件（Plus / PULS 版本）
├─ 模型文件/                           # 3D STEP 模型
├─ Docs/                               # 参考资料（TI《高速低侧电流检测参考设计》）
├─ Image/                              # 文档配图
└─ CHANGELOG.md                        # 版本更新日志
```

## 固件代码

本仓库为**纯硬件工程**，不包含固件源码。固件由以下两个独立仓库提供，与本硬件配套使用：

| 仓库 | 说明 |
| --- | --- |
| [**RM-CODE-SuperCapControlBoard_Plus**](https://github.com/DonotFreeze/RM-CODE-SuperCapControlBoard_Plus) | RM2025 赛季超级电容控制板 Plus 的 **CubeMX 代码初始化工程**，提供 STM32 底层外设的 CubeMX 配置 |
| [**RM-SuperCapCtrlLib**](https://github.com/DonotFreeze/RM-SuperCapCtrlLib) | 参加 RoboMaster 机甲大师赛期间开发的 **C 语言库**，可同时用于超级电容控制板 **Lite 和 Plus**，负责充放电环路控制与对外接口 |

## 物料与打样

- BOM 已附立创商城编号，可直接一键下单；建议一次性采购 10 套用量以获得较优价格（约 90 元/套，2025 年 5 月）。
- 全部芯片若在优信电子采购，成本可再降低约 20 元/套（其中 **MP2456 强烈建议到优信购买**）。
- 磁环电感立创商城无货、未列入 BOM，需自行采购 **106-125 磁环**（四线 1.0mm 并绕 11 匝，初始感量约 22µH），磁芯型号务必一致以保证感量与饱和电流。

---

## 参考文献

- 高速低侧电流检测参考设计 (Rev. C) —— 见 `Docs/《高速低侧电流检测参考设计-TI》.pdf`
- 电源远端电压补偿 / 远端补偿电源电路 —— CSDN 博客

## 特别鸣谢

感谢以下战队在 Lite 版本中的使用反馈（排名不分先后，想到谁就写谁）：

- 江南大学霞客湾校区 - SHARK 战队
- 北京理工大学珠海学院 - 毅恒战队
- 厦门大学嘉庚学院 - TCR 战队
- 宁波诺丁汉大学 - AIM 战队
- 浙江理工大学 - 钱塘蛟战队

## 许可证

本作品采用 [CC-BY-4.0](https://creativecommons.org/licenses/by/4.0/legalcode) 许可协议进行授权，欢迎转载，但请务必保留作者署名。

## 相关链接

- [RM2025 超级电容控制板 Plus「硬件篇」](https://donotfreeze.github.io/robomaster/supercap-controller-plus-hardware/)（本工程的设计说明）
- [固件代码 · RM-CODE-SuperCapControlBoard_Plus](https://github.com/DonotFreeze/RM-CODE-SuperCapControlBoard_Plus)（CubeMX 代码初始化工程）
- [固件代码 · RM-SuperCapCtrlLib](https://github.com/DonotFreeze/RM-SuperCapCtrlLib)（Lite / Plus 通用的 C 语言库）
- [RM2024 超级电容控制板 Lite「硬件篇」](https://donotfreeze.github.io/robomaster/supercap-controller-lite-hardware/)
- [RM2025 超级电容模组 Plus「使用手册」](https://donotfreeze.github.io/robomaster/supercap-module-plus-user-manual/)
- [RM24-25 超级电容控制板 Lite & Plus「CubeMX 篇」](https://donotfreeze.github.io/robomaster/supercap-controller-cubemx/)
- [RM24-25 超级电容模组 Lite & Plus「答疑篇」](https://donotfreeze.github.io/robomaster/supercap-module-faq/)
- [DonotFreeze 的知识库](https://donotfreeze.github.io/)

## KiCad design SuperCapControlBoard_Plus.kicad_pcb

Parts:
C1, C3, C8, C9, C10, C11, C13, C16, C18, C19, C20, C21: 100nF; C_0603_1608Metric
C2, C12, C17, C22: 4.7uF; C_0603_1608Metric
C4, C5, C6: 47nF; C_0603_1608Metric
C7: 1nF; C_0603_1608Metric
C14, C15: 12pF; C_0603_1608Metric
D1: XL-3210UGC; LED_1204_3210
D2: XL-3210UBC; LED_1204_3210
D3: PESD24VL2B; SOT-23
D4: XL-3210SURC; LED_1204_3210
J1: MMCX-KWE; MMCX_KWE_TH_Horizontal
J2: MMCX-KWE; MMCX_KWE_TH_Horizontal; not fitted
J3: MX1.25-2PIN; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical
J4: GH1.25-2PIN; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J5: GH1.25-4PIN; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J6, J7: ZH1.5_4PIN; JST_ZH_1x04_-1MP_P1.5mm_MIX_MX_1x04-1MP_P1.25_Horizontal
R1, R2, R3, R4, R5, R6, R30, R35: 10K; R_0603_1608Metric
R7, R8, R9, R10: 1M; R_0603_1608Metric
R11, R17: 200K; R_0603_1608Metric
R12: 20K; R_0603_1608Metric
R13, R14, R15, R16: 62K; R_0603_1608Metric
R18, R19, R20, R21: 330R; R_0603_1608Metric
R22, R25, R33, R34: 47R; R_0603_1608Metric
R23, R24, R27, R32: 4K7; R_0603_1608Metric
R26, R29, R31: 47K; R_0603_1608Metric
R28: 120R; R_0603_1608Metric
R36: 3K3; R_0603_1608Metric
SW1: TS-1086EV-16; SW_Push_1P1T-MP_NO_TS-1086EV-AR03526
SW2: DIP-1PIN-TH; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
TH1: B3950-100K; R_0603_1608Metric
TP1: I_Bat; TestPoint_Pad_D1.5mm
TP2: I_MOS; TestPoint_Pad_D1.5mm
TP3: TEST_OUT; TestPoint_Pad_D1.5mm
U1, U5, U6: USBLC6-2SC6; SOT-23-6
U2: INA193; SOT-23-5
U3: TLV9061; SOT-23-5
U4: TCAN1044; SOT-23-8
U7: STM32G431CxTx; LQFP-48_7x7mm_P0.5mm
Y1: 25M; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C1.1, C2.1, C3.2, C12.2, C16.2, C19.2, C20.2, C21.2, C22.2, J6.4, R26.2, R31.2, R35.1, U1.5 (VBUS), U2.5 (V+), U3.5 (V+), U4.5 (VIO), U5.5 (VBUS), U6.5 (VBUS), U7.1 (VBAT), U7.21 (VDDA), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD); also elsewhere on the board
+5V: C9.2, J7.4, U4.3 (VDD); also elsewhere on the board
/0.82V: R11.2, U7.10 (PA2)
/BOOM_IN: U5.6 (I/O1), U7.27 (PB13)
/CAN_H: D3.1 (K), J4.2, J5.3, R28.1, U4.7 (CANH)
/CAN_L: D3.2 (K), J4.1, J5.4, SW2.1, U4.6 (CANL)
/CAN_RX: R25.1, U7.33 (PA11)
/CAN_TX: R22.1, U7.34 (PA12)
/I_Bat: C4.2, R18.1, TP1.1, U7.9 (PA1)
/I_MOS: C7.2, R21.2, TP2.1, U7.8 (PA0)
/LED_B: R24.2, U7.2 (PC13)
/LED_G: R23.2, U7.3 (PC14)
/LED_R: R27.2, U7.4 (PC15)
/MCU_RX: J7.2, U7.44 (PB7)
/MCU_TX: J7.1, U7.43 (PB6)
/OPA2_N: R8.1, R14.2, U7.13 (PA5)
/OPA2_OUT: R14.1, R19.1, U7.14 (PA6)
/OPA2_P: R7.2, R13.1, U7.15 (PA7)
/OPA3_N: R10.1, R16.2, U7.22 (PB10)
/OPA3_OUT: R16.1, R20.1, U7.17 (PB1)
/OPA3_P: R9.2, R15.1, U7.16 (PB0)
/RST: C18.2, SW1.1, U7.7 (PG10)
/Temp_Cap: C11.1, J3.2, R31.1, U7.29 (PB15)
/Temp_MOS: C8.1, R26.1, TH1.1, U7.25 (PB11)
/Vsense_Bat: C5.2, R19.2, U7.12 (PA4)
/Vsense_Cap: C6.2, R20.2, U7.18 (PB2)
Enable: U7.42 (PB5); also elsewhere on the board
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.1, C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, D1.1 (K), D1.3 (PAD), D2.1 (K), D2.3 (PAD), D3.3 (A), D4.1 (K), D4.3 (PAD), J3.1, J3.MP (MountPin), J4.MP (MountPin), J5.MP (MountPin), J6.3, J6.MP (MountPin), J7.3, J7.MP (MountPin), R4.2, R6.2, R12.1, R13.2, R15.2, R30.1, R32.2, R36.2, SW1.2, SW1.MP, TH1.2, U1.2 (GND), U2.2 (GND), U3.2 (V-), U4.2 (GND), U4.8 (STB), U5.2 (GND), U6.2 (GND), U7.19 (VSSA), U7.23 (VSS), U7.35 (VSS), U7.47 (VSS), Y1.2, Y1.4; also elsewhere on the board
HIN: U7.31 (PA9); also elsewhere on the board
I_MOS+: R2.2; also elsewhere on the board
I_MOS-: R1.1; also elsewhere on the board
I_bat+: U2.3 (+); also elsewhere on the board
I_bat-: U2.4 (-); also elsewhere on the board
LIN: U7.28 (PB14); also elsewhere on the board
unnamed: C10.1, R29.1, R30.2, U5.1 (I/O1)
unnamed: D1.2 (A), R23.1
unnamed: D2.2 (A), R24.1
unnamed: D4.2 (A), R27.1
unnamed: J1.2 (Ext), R4.1, R8.2
unnamed: J1.1 (In), R3.1, R7.1
unnamed: J2.2 (Ext), R6.1, R10.2
unnamed: J2.1 (In), R5.1, R9.1
unnamed: J6.1, R33.2
unnamed: J6.2, R34.2
unnamed: R1.2, U1.1 (I/O1)
unnamed: R2.1, U1.3 (I/O2)
unnamed: R12.2, R18.2, U2.1
unnamed: R17.2, R21.1, U3.1
unnamed: R28.2, SW2.2
unnamed: R33.1, U6.4 (I/O2)
unnamed: R34.1, U6.6 (I/O1)
unnamed: R11.1, U1.4 (I/O2), U3.3 (+)
unnamed: R17.1, U1.6 (I/O1), U3.4 (-)
unnamed: R25.2, U4.4 (RXD)
unnamed: R22.2, U4.1 (TXD)
unnamed: R35.2, R36.1, U7.11 (PA3)
unnamed: R32.1, U7.45 (PB8)
unnamed: TP3.1, U7.46 (PB9)
unnamed: C14.1, U7.5 (PF0), Y1.3
unnamed: C15.1, U7.6 (PF1), Y1.1
unnamed: C13.2, C17.2, U7.20 (VREF+)
SWCLK: U6.1 (I/O1), U7.38 (PA14)
SWDIO: U6.3 (I/O2), U7.37 (PA13)
TIM1_BKIN: U7.26 (PB12); also elsewhere on the board
Vbat: R3.2; also elsewhere on the board
Vboost: R29.2; also elsewhere on the board
Vcap: R5.2; also elsewhere on the board

Notes on the sheet:
CAN收发器
J6和J7的焊盘兼容MX1.25或者GH1.25
爆炸检测
电压检测/远端补偿
G431主控
调试口
外接热敏电阻 B3950-100K
电流检测
复位/复用按键
状态指示灯
热敏电阻温度检测

Parts:
C23, C44, C45, C46, C56, C58: 10uF; C_0603_1608Metric
C24, C25, C35, C36, C37, C51, C52, C54, C55: 10uF; C_1206_3216Metric
C26, C28, C48, C50: 100uF; CP_Radial_D8.0mm_P3.50mm
C27, C29, C30, C31, C32, C33, C34, C38, C39, C41, C42, C43, C47, C49, C53, C57, C59, C60: 100nF; C_0603_1608Metric
C40: 22nF; C_0603_1608Metric
D5: SMF26A; D_SMF
D6: SMF12A; D_SMF
D7, D8: 1N5819WS; D_SOD-323_HandSoldering
D9: SB1045L; TO-277A
D10, D11: SMCJ28A; D_SMC
D12: 1N5819W; D_SOD-123F
F1: 1206L010/60NR; Fuse_1206_3216Metric
F2: 2010T5A250V; Fuse_Littelfuse_395Series
H1, H2, H3, H4: M3; MountingHole_4mm_Pad
L1: 330R@100Mhz; L_0805_2012Metric
L2, L3: APSWPA252012S220MTF; L_Sunlord_SWPA252012S
L4: 106-125_FerriteCore_22uH; L_106125
Q1: DTC143ZCA; SOT-23
Q2: AGM60P100A; AO_DFN-8-1EP_5.55x5.2mm_P1.27mm_EP4.12x4.6mm
Q3, Q4: IRFH7440; TDSON-8-1
R37: 47R; R_0603_1608Metric
R38, R39, R52, R53, R54, R55: 4K7; R_0603_1608Metric
R40, R41, R42, R47, R48: 47K; R_0603_1608Metric
R43, R44: 3K3; R_0603_1608Metric
R45, R46: 0R; R_0603_1608Metric
R49: 39K; R_0603_1608Metric
R50: 18K; R_0603_1608Metric
R51: R002; R_Shunt_2512_6332Metric
R56: R004; R_Shunt_2512_6332Metric
TP4: 24V; TestPoint_Pad_D1.5mm
TP5, TP13: 5V; TestPoint_Pad_D1.5mm
TP6: Vboost; TestPoint_Pad_D1.5mm
TP7, TP9, TP12, TP14, TP17, TP19: GND; TestPoint_Pad_D1.5mm
TP8: LG; TestPoint_Pad_D1.5mm
TP10: HG; TestPoint_Pad_D1.5mm
TP11: 3V3; TestPoint_Pad_D1.5mm
TP15: SW; TestPoint_Pad_D1.5mm
TP16: Vcap; TestPoint_Pad_D1.5mm
TP18: Vbat; TestPoint_Pad_D1.5mm
TP20: PMOS_CTRL; TestPoint_Pad_D1.5mm
TP21: TIM1_BKIN; TestPoint_Pad_D1.5mm
U8, U9: MP2456; SOT-23-6
U10: RT9193; SOT-23-5
U11: 74LVC1G32; SOT-23-5
U12: 74LVC1G08; SOT-23-5
U13: LM5109; SOIC-8_3.9x4.9mm_P1.27mm
XT1, XT2: XT30U-M; AMASS_XT30U-M_1x02_P5.0mm_Vertical
XT3: XT30U-F; AMASS_XT30U-F_1x02_P5.0mm_Vertical

Connections:
+3V3: C41.1, C44.1, C53.1, C57.1, TP11.1, U10.5 (VOUT), U11.5 (VCC), U12.5 (VCC); also elsewhere on the board
+5V: C42.1, C46.1, L1.1, L3.2, R50.2, TP13.1; also elsewhere on the board
+10V: C43.1, C45.1, C58.2, C59.1, D12.2 (A), L2.2, R49.2, U13.1 (VDD)
Enable: R52.2, R53.2, U11.1, U12.1; also elsewhere on the board
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.1, C52.1, C53.2, C54.1, C55.1, C56.2, C57.2, C58.1, C59.2, D5.2 (A2), D7.2 (A), D8.2 (A), D10.2 (A), D11.2 (A), H1.1, H2.1, H3.1, H4.1, Q1.2 (E), R43.2, R44.2, R47.2, R51.4, R53.1, R54.2, R55.2, TP7.1, TP9.1, TP12.1, TP14.1, TP17.1, TP19.1, U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.3 (GND), U12.3 (GND), U13.4 (VSS), XT1.1 (-), XT2.1 (-), XT3.1 (-); also elsewhere on the board
HIN: R54.1, U13.2 (HI); also elsewhere on the board
HO: R46.1, U13.7 (HO)
I_MOS+: R51.2; also elsewhere on the board
I_MOS-: R51.3; also elsewhere on the board
I_bat+: R56.2; also elsewhere on the board
I_bat-: R56.3; also elsewhere on the board
L0: R45.1, U13.5 (LO)
LIN: R55.1, U13.3 (LI); also elsewhere on the board
unnamed: C56.1, R52.1, U11.2, U12.2
unnamed: C24.1, C25.1, C29.1, C30.1, D5.1 (A1), R37.2, R41.1, R42.1, TP4.1, U8.5 (VIN), U9.5 (VIN)
unnamed: D6.2 (A2), Q2.4 (G), R38.2, R39.1
unnamed: C38.2, D7.1 (K), L3.1, U9.6 (SW)
unnamed: C39.2, D8.1 (K), L2.1, U8.6 (SW)
unnamed: D9.1 (A), D9.2 (A), Q4.1 (S), Q4.2 (S), Q4.3 (S), R51.1
unnamed: C60.1, D12.1 (K), U13.8 (HB)
unnamed: F1.2, R37.1
unnamed: Q1.3 (C), R38.1
unnamed: F2.2, Q2.5 (D)
unnamed: Q3.4 (G), R46.2, R48.1, TP10.1
unnamed: Q4.4 (G), R45.2, R47.1, TP8.1
unnamed: C39.1, U8.1 (BST)
unnamed: C33.2, R41.2, U8.4 (EN)
unnamed: R43.1, R49.1, U8.3 (FB)
unnamed: C38.1, U9.1 (BST)
unnamed: C34.2, R42.2, U9.4 (EN)
unnamed: R44.1, R50.1, U9.3 (FB)
unnamed: C40.1, U10.4 (BP)
unnamed: R40.2, U10.3 (EN)
unnamed: C23.1, C27.1, L1.2, R40.1, TP5.1, U10.1 (VIN)
PMOS_CTRL: Q1.1 (B), TP20.1, U11.4
SW: C60.2, D9.3 (K), L4.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R48.2, TP15.1, U13.6 (HS)
TIM1_BKIN: TP21.1, U12.4; also elsewhere on the board
Vbat: D11.1 (K), R56.1, TP18.1, XT2.2 (+); also elsewhere on the board
Vboost: C26.1, C28.1, C31.2, C32.2, C35.2, C36.2, C37.2, D6.1 (A1), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.5 (D), R39.2, TP6.1; also elsewhere on the board
Vcap: C47.1, C48.1, C49.1, C50.1, C51.2, C52.2, C54.2, C55.2, D10.1 (K), L4.1, TP16.1, XT1.2 (+); also elsewhere on the board
Vchassis: F1.1, F2.1, R56.4, XT3.2 (+)

Notes on the sheet:
机械孔
PMOS关断电路
半桥与PMOS开关延迟电路
这个磁环电感在淘宝买，或者自己绕
这里的电容全部使用耐压50V或者以上的
主拓扑
底盘并联支路
辅助电源

Board: 4 copper layers, 75.0 x 45.0 mm, 190 parts (17 on the bottom side), 94 nets.

## Commit log (part)

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2026-03-06 建立仓库
2026-03-07 添加LICENSE
2026-03-07 添加GERBER文件，更正PCB版本丝印为2605
2026-03-29 ``` docs(README): 更新技术文档说明并修正描述错误
    - 将全差分放大器重要性说明加粗强调
    - 修正下管续流采样误差问题的描述，澄清软件限制措施
    - 调整保险丝熔断检测章节标题层级
    - 修正PMOS与PWM时序延迟保护章节标题层级
    - 优化电源远端电压补偿参考链接格式
    - 在STM32引脚说明中明确BOOM_IN引脚标识
